# Keil uVision project ThunderLib3.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ThunderLib3
  c flags: Optim=3 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --cpp11
  c include: ..\Lib\inc;..\Lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Lib
    ../Lib/src/: gpio.cpp sys.cpp usart.cpp
  group APP
    ./: main.cpp startup_stm32f10x_hd.s
